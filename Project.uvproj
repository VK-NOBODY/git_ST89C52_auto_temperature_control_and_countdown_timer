# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c UART.c UART.h XPT2046.c XPT2046.h Timer0.c Timer0.h Delay.c Delay.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h DS18B20.c DS18B20.h OneWire.c OneWire.h Nixie.c Nixie.h ired.c public.c smg.c ired.h public.h smg.h AT24C02.c AT24C02.h Key.c Key.h I2C.c I2C.h MatrixLED.c MatrixLED.h
